# Repository Felicitymecha/gerbalino

## EAGLE design edp_millerv0.3.brd

Parts:
12VPW_SUPPLY: 691101710002
ATMEGA328PAU: ATMEGA8-AU; TQFP32-08
C1, C4: 22pF; 1206
C2, C3, C18: 100uF; UD-10X10_NICHICON
C5, C7: 0.1uF; 1206
C6: 0.33uF; 1206
DC_MOTOR: 691103110003
ENDSTOP_X: 691103110002
ENDSTOP_Y: 691103110002
ENDSTOP_Z, ENDSTOP_Z1, ENDSTOP_Z2, ENDSTOP_Z3, ENDSTOP_Z4, ENDSTOP_Z5: 691103110002
FTDI: M06SMD; 1X06-SMD
IC1: 7805TV; TO220V
JP1, JP2, JP10: M04LONGPADS; 1X04_LONGPADS
JP4, JP5, JP6: PINHD-2X3-SMD; 2X03SMD
Q1: 16mhz; CSM-7X-DU
R1: 10k; 1206
R2, R3, R4, R5, R10, R11: 0; 1206
R6, R7, R8, R9: 499; 1206
S1: 6MM_SWITCH6MM_SWITCH; 6MM_SWITCH
U$1, U$2, U$3: POLOLU_A4983CARRIER; A4988BREAKOUT
U$4, U$5, U$6, U$7: LED1206; 1206

Connections:
+5V: ATMEGA328PAU.4 (VCC), ATMEGA328PAU.6 (VCC), ATMEGA328PAU.18 (AVCC), ATMEGA328PAU.20 (AREF), C7.1, IC1.3 (VO), JP4.2, JP4.4, JP4.6, JP5.1, JP5.3, JP5.5, JP6.1, JP6.3, JP6.5, R1.2, U$1.VDD, U$2.VDD, U$3.VDD, U$4.1 (A)
+24V: 12VPW_SUPPLY.2, C2.+, C3.+, C6.2, C18.+, ENDSTOP_Z4.1, ENDSTOP_Z5.1, IC1.1 (VI), U$1.VMOT, U$2.VMOT, U$3.VMOT
COOL: ATMEGA328PAU.26 (PC3(ADC3)), ENDSTOP_Z1.2
DIR_X: ATMEGA328PAU.9 (PD5(T1)), U$3.DIR
DIR_Y: ATMEGA328PAU.10 (PD6(AIN0)), R10.1
DIR_Z: ATMEGA328PAU.11 (PD7(AIN1)), U$2.DIR
ENABLE: ATMEGA328PAU.12 (PB0(ICP1)), R11.1, R11.2, U$1.EN, U$2.EN, U$3.EN, U$7.1 (A)
GND: 12VPW_SUPPLY.1, ATMEGA328PAU.3 (GND), ATMEGA328PAU.5 (GND), ATMEGA328PAU.21 (AGND), C1.1, C2.-, C3.-, C4.1, C6.1, C7.2, C18.-, DC_MOTOR.1, ENDSTOP_X.2, ENDSTOP_Y.2, ENDSTOP_Z.2, ENDSTOP_Z1.1, ENDSTOP_Z2.2, ENDSTOP_Z3.1, ENDSTOP_Z4.2, ENDSTOP_Z5.2, FTDI.5, FTDI.6, IC1.2 (GND), R2.1, R2.2, R4.1, R4.2, R5.1, R5.2, R6.1, R7.1, R8.1, R9.1, S1.3 (S), S1.4 (S1), U$1.GND, U$1.GND@0 (GND), U$2.GND, U$2.GND@0 (GND), U$3.GND, U$3.GND@0 (GND)
GRBL_RESET: ATMEGA328PAU.23 (PC0(ADC0)), ENDSTOP_Z3.2
LIMIT_X: ATMEGA328PAU.13 (PB1(OC1A)), ENDSTOP_X.1
LIMIT_Y: ATMEGA328PAU.14 (PB2(SS/OC1B)), ENDSTOP_Y.1
MISO: ATMEGA328PAU.16 (PB4(MISO)), ENDSTOP_Z.1
MOSI: ATMEGA328PAU.15 (PB3(MOSI/OC2)), DC_MOTOR.2
unnamed: R7.2, U$4.2 (C)
unnamed: C5.1, FTDI.1
unnamed: R6.2, U$5.2 (C)
unnamed: R8.2, U$6.2 (C)
unnamed: JP1.1, U$1.2B
unnamed: JP1.2, U$1.2A
unnamed: JP1.3, U$1.1A
unnamed: JP1.4, U$1.1B
unnamed: JP10.1, U$3.2B
unnamed: JP10.2, U$3.2A
unnamed: JP10.3, U$3.1A
unnamed: JP10.4, U$3.1B
unnamed: JP2.1, U$2.2B
unnamed: JP2.2, U$2.2A
unnamed: JP2.3, U$2.1A
unnamed: JP2.4, U$2.1B
unnamed: U$1.RST, U$1.SLP (SLEEP)
unnamed: U$3.RST, U$3.SLP (SLEEP)
unnamed: R9.2, U$7.2 (C)
unnamed: R10.2, U$1.DIR
unnamed: U$2.RST, U$2.SLP (SLEEP)
unnamed: ATMEGA328PAU.8 (PB7(XTAL2/TOSC2)), C4.2, Q1.1
unnamed: JP5.6, U$2.MS3
unnamed: JP5.4, U$2.MS2
unnamed: JP5.2, U$2.MS1
unnamed: JP4.1, U$1.MS3
unnamed: JP4.3, U$1.MS2
unnamed: JP4.5, U$1.MS1
unnamed: JP6.6, U$3.MS3
unnamed: JP6.4, U$3.MS2
unnamed: JP6.2, U$3.MS1
unnamed: ATMEGA328PAU.7 (PB6(XTAL1/TOSC1)), C1.2, Q1.2
unnamed: R3.2, U$1.STEP
PROBE: ATMEGA328PAU.28 (PC5(ADC5/SCL)), ENDSTOP_Z2.1
RESET: ATMEGA328PAU.29 (PC6(/RESET)), C5.2, R1.1, S1.1, S1.2 (P1)
RX: ATMEGA328PAU.30 (PD0(RXD)), FTDI.3, U$6.1 (A)
SCK: ATMEGA328PAU.17 (PB5(SCK)), DC_MOTOR.3
STEP_X: ATMEGA328PAU.32 (PD2(INT0)), U$3.STEP
STEP_Y: ATMEGA328PAU.1 (PD3(INT1)), R3.1
STEP_Z: ATMEGA328PAU.2 (PD4(T0/XCK)), U$2.STEP
TX: ATMEGA328PAU.31 (PD1(TXD)), FTDI.2, U$5.1 (A)

Board: 2 copper layers, 47 parts (4 on the bottom side), 54 nets.

## Commit log

2015-10-21 gerbalino bug fixes v0.3.1

Notices in the files:
parts and their libraries:
Wurth_Elektronik_Electromechanic_Termina: Copyright: Würth Elektronik
01_SparkFun: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
